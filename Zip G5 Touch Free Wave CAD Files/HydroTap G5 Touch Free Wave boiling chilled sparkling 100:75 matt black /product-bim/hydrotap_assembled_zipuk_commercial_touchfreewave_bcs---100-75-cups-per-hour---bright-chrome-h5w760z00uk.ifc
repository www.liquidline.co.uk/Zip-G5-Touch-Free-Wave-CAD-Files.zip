Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2021-09-09T17:05:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.10.28 - Exporter 22.0.10.28 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 09 17:05:06 2021 * Host: DESKTOP-QB16J48 * Database: C:\Users\Glenn\AppData\Local\Temp\b05f7b85-a1d0-447a-9c05-9af200eb2c2b\60188e62-ae05-452b-9696-d1f50aa0a121\ifc * Database version: 5507 * Database creation date: Thu Sep 09 17:05:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 09 17:05:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 09 17:05:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -33, -52, -1, -696472; RefLongitude: 151, 12, 25, 587158; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: Ground Floor
Pset_ProductRequirements - Name: Ground Floor; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_1492177 | SOURCE
Port_1492177 | SOURCEANDSINK

# IfcElementAssembly: Plumbing Fixtures Assembly:HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK), Plumbing Fixtures Assembly:HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK):1497640
In: Ground Floor
PredefinedType: USERDEFINED
Pset_ProductRequirements - Category: Assemblies
Pset_QuantityTakeOff - Reference: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK)
Identity Data - Naming Category: Plumbing Fixtures
Other - Category: Assemblies; Family: Plumbing Fixtures Assembly: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK); Family and Type: Plumbing Fixtures Assembly: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK); Type: Plumbing Fixtures Assembly: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK); Type Id: Plumbing Fixtures Assembly: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK)
Phasing - Phase Created: New Construction
Identity Data(Type) - Type Name: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK)
Other(Type) - Category: Assemblies; Family Name: Plumbing Fixtures Assembly

# IfcFlowTerminal: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS:100/75 cups per hour - Bright Chrome (H5W760Z00UK), HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS:100/75 cups per hour - Bright Chrome (H5W760Z00UK):1492177
In: Ground Floor
Type - Material: Metal_BrightChrome_Zip, Metal_BrushedStainlessSteel_Zip
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Manufacturer_Overall Depth: 483 mm; Manufacturer_Overall Height: 333 mm; Manufacturer_Overall Width: 339 mm
Type - Electrical - Electrical Connection: yes
Type - Identity Data - CreatedBy_ANZRS: IGS BIM Solutions; CreatedByURL_ANZRS: https://igsgroup.com.au; Description: With an increased consideration around hygiene in the workplace, the new Zip HydroTap Touch Free Wave uses smart infrared sensors to provide a 100% touch-free, safe to use solution for workplaces to access instant boiling, chilled and sparkling drinking water with a simple wave of the hand. A reliable solution for a range of locations, the tap boasts a number of safety features to prevent the accidental dispense of water. Like all our other HydroTaps, the Touch Free Wave offers cutting-edge technology to conserve water, energy and time, with market-leading 0.2 micron filtration GÇô 25 times more effective than a standard water filter jug.; Manufacturer: Zip Water UK; Manufacturer_Spec Code: H5W760Z00UK; Manufacturer_URL__Product Specific: https://specify.zipwater.co.uk/products/hydrotap/touch-free-wave/work; Model: 100/75 cups per hour - Bright Chrome; ModifiedIssue_ANZRS: 20210826; OmniClass Number: 23.21.21.25; Type Comments: HydroTap Wave BCS - Bright Chrome - 100/75 cups per hour; Type Name: 100/75 cups per hour - Bright Chrome (H5W760Z00UK); Uniclass2015Code: Pr_40_70_23_42; Uniclass2015Title: Instant boiling and cold water taps; Uniclass2015Version: Products v1.17; URL: https://www.zipwater.co.uk/
Type - Materials and Finishes - FixtureMaterial: Metal_BrightChrome_Zip
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: UKCA and CE marked; ColdWaterOffset: 22.9 mm; Color: Bright Chrome; CommandCentre: 339w x 483d x 333h (BCS); ElectricalOffset: 45.1 mm; Family Name: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS; Grade: Commercial; Size: 339 x 483 x 333 mm; SustainabilityPerformance: RoHS and WEEE compliant
Type - Visibility - Booster: no
Type - Pset_ElementShading - Color: Bright Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: Zip Water UK
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: Metal_BrushedStainlessSteel_Zip, Metal_PowderCoat_Zip_White, Metal_BrightChrome_Zip, Black_Zip
Pset_DistributionFlowElementCommon - Reference: 100/75 cups per hour - Bright Chrome (H5W760Z00UK); sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Construction - CommandCentreFrontAndBackOffset: 0 mm; CommandCentreLeftAndRightOffset: 0 mm; CommandCentreTopOffset: 800 mm; DispenserRotation: 0 deg; GasCylinderSideOffset: 100 mm; Manufacturer_Height From FFL: 900 mm
Dimensions - Area: 2.14807 m2; Volume: 0.191108 m3
Identity Data - Assembly Name: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS 100/75 cups per hour - Bright Chrome (H5W760Z00UK); Mark: 190
Mechanical - System Classification: Domestic Cold Water,Power
Other - CommandCentreOffsetBack: 0 mm; CommandCentreOffsetForward: 0 mm; CommandCentreOffsetLeft: 0 mm; CommandCentreOffsetRight: 0 mm; CommandCentreTopOffsetCalc: 800 mm; Family: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS: 100/75 cups per hour - Bright Chrome (H5W760Z00UK); Family and Type: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS: 100/75 cups per hour - Bright Chrome (H5W760Z00UK); GasCylinderOffsetLeft: 0 mm; GasCylinderOffsetRight: 339.5 mm; Type: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS: 100/75 cups per hour - Bright Chrome (H5W760Z00UK); Type Id: HydroTap_Assembled_ZipUK_Commercial_TouchFreeWave_BCS: 100/75 cups per hour - Bright Chrome (H5W760Z00UK); VentTrayCalc: no
Phasing - Phase Created: New Construction
Visibility - Font: no; FontRaised: no; RequiredSpace: yes; VentTray: yes
